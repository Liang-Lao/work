# Keil uVision project MDK_Template.uvprojx, settings and files
target Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: MDK_Template +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ..\User\bsp\inc;..\User\bsp;..\Libraries\CMSIS\Core;..\Libraries\CMSIS;..\Libraries\STM32H7xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Doc
    ../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
  group User
    ../User/: main.c
  group BSP
    ../User/bsp/: bsp.c bsp.h stm32h7xx_it.c
    ../User/bsp/src/: bsp_fmc_io.c bsp_key.c bsp_led.c bsp_timer.c bsp_uart_fifo.c
  group CMSIS
    ../Libraries/CMSIS/: startup_stm32h743xx_mdk.s stm32h743xx.h system_stm32h7xx.c
  group HAL_Driver
    ../Libraries/STM32H7xx_HAL_Driver/Inc/: stm32h7xx_hal_conf.h
    ../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c
  group HardFault
    ../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
